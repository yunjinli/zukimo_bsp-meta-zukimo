FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-12-and-16-bit-bayer-formats-from-main-branch.patch"


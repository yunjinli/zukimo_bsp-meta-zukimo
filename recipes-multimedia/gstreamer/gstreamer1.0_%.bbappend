PACKAGECONFIG:append = " gst-tracer-hooks tracer-hooks coretracers"